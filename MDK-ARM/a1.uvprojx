# Keil uVision project a1.uvprojx, settings and files
target a1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: a1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\CLRC663\comps\phhalHw\src\Rc663;   ..\CLRC663\comps\phbalReg\src\Stub;   ..\CLRC663\comps\phKeyStore\src\Rc663;   ..\CLRC663\comps\phalI15693\src\Sw;   ..\CLRC663\phSubBal\include;   ..\CLRC663\intfs;   ..\CLRC663\types;   ..\CLRC663;   ..\CLRC663_Interface;   ..\CLRC663\comps\phalI15693\src;   ..\CLRC663\comps\phalI15693\src\Sw;   ..\CLRC663\comps\phalSli\src;   ..\CLRC663\comps\phalSli\src\Sw;   ..\CLRC663\intfs;   ..\CLRC663\comps\phbalReg\src\SerialWin
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c aes.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CLRC663
    ../CLRC663/comps/phhalHw/src/: phhalHw.c
    ../CLRC663/phSubBal/src/: RegCtl_SpiHw.c
    ../CLRC663/comps/phbalReg/src/: phbalReg.c
    ../CLRC663/comps/phbalReg/src/Stub/: phbalReg_Stub.c
    ../CLRC663/comps/phalI15693/src/: phalI15693.c
    ../CLRC663/comps/phalI15693/src/Sw/: phalI15693_Sw.c
    ../CLRC663/comps/phpalMifare/src/: phpalMifare.c
    ../CLRC663/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c
    ../CLRC663/comps/phhalHw/src/Rc663/: phhalHw_Rc663.c phhalHw_Rc663_Cmd.c phhalHw_Rc663_Int.c phhalHw_Rc663_Wait.c
    ../CLRC663/comps/phKeyStore/src/Rc663/: phKeyStore_Rc663.c
    ../CLRC663/comps/phLog/src/: phLog.c
    ../CLRC663/comps/phKeyStore/src/: phKeyStore.c
    ../CLRC663/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c
    ../CLRC663/comps/phalMfc/src/Sw/: phalMfc_Sw.c
    ../CLRC663/comps/phTools/src/: phTools.c
    ../CLRC663/comps/phpalI14443p4/src/: phpalI14443p4.c
    ../CLRC663/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ../CLRC663/comps/phpalSli15693/src/: phpalSli15693.c
    ../CLRC663/comps/phpalSli15693/src/Sw/: phpalSli15693_Sw.c
software components: CMSIS:CORE 4.3.0
